Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-10-19T17:16:17+02:00
Written by: IfcOpenShell 0.9.0.post1
Made in: IfcOpenShell 0.9.0.post1
Authorization: Nobody

# IfcFurniture: Sitzbank, Sitzbank Ufenau Vierkantrohr mit Lehne, L 2500 mm
In: Standort
Pset_ManufacturerTypeInformation - Manufacturer: Obersee Holzwerke (Karawan Holz GmbH); ModelLabel: Sitzbank Ufenau Vierkantrohr mit Lehne, L 2500 mm; ModelReference: UFENAU-VKT-2500-L
OH_Abmessungen - Laenge_mm: 2500; Sitzhoehe_mm: 453; Sitztiefe_mm: 410; Gesamthoehe_mm: 820; Gewicht_ca_kg: 83; Stuetze: Vierkantrohr 80 × 80 × 4 mm; Material: Lärche, Stahl S235 feuerverzinkt + pulverbeschichtet schwarz matt
